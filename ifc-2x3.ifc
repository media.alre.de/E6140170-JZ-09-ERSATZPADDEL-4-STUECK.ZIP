Properties of the parts of a building model (IFC2X3)

# File
Description: Ersatzpaddel (4 Stück) für Strömungswächter JSF, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: E6140170, Ersatzpaddel (4 Stück) für Strömungswächter JSF
In: Raum
Description: Ersatzpaddel (4 Stück), von 1“… 8“ für Strömungswächter JSF; Classification: EC011319 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: E6140170; ModelLabel: JZ-09; GlobalTradeItemNumber: 4050528031242; ProductURL: https://alre.de/produkt_E6140170
Pset_Specification - NominalLength: 0.167 m; NominalWidth: 0.029 m; NominalDepth: 0.001 m; NetWeight: 0.015
Pset_ALRE_ETIM_Properties - Ersatzteil: yes; ETIM-Klasse: EC011319; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-E6140170.pdf
